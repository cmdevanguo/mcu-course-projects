ORG 0000H
AJMP START
ORG 001BH
AJMP TINT
ORG 0030H
START:MOV R3,#64
MOV R1,#0
MOV TMOD,#10H
MOV TH1,#0E3H
MOV TL1,#0E0H
MOV A,#0F0H
SETB TR1
SETB EA
SETB ET1
SJMP $
TINT:DJNZ R3,BACK
CJNE R1,#1,NEXT
SJMP LAST
NEXT: RL A
MOV P1,A
CJNE A,#0FH,NE1
MOV R1,#1
NE1:MOV R3,#64
SJMP BACK
LAST:RR A
MOV P1,A
CJNE A,#0F0H,LA1
MOV R1,#0
LA1:MOV R3,#64
SJMP BACK
BACK:MOV TH1,#0E3H
MOV TL1,#0E0H
RETI
END