ORG 0000H
START:MOV A,#0F7H
MOV	R3,#4
LOOP:RL	A           
MOV	P1, A
LCALL DELAY		
DJNZ R3,LOOP
AJMP START
DELAY:MOV R1,#255   
DEL1:MOV R2,#255
DEL2:
NOP
NOP
NOP
NOP
NOP
NOP
NOP
NOP
NOP
NOP
DJNZ R2,DEL2
DJNZ R1,DEL1
RET
END